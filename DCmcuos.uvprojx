# Keil uVision project DCmcuos.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DCmcupivot
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=6 wLevel=1
  c include: .\API;.\main\include;.\RTOS\include;.\main\include;.\vcpkg\packages\etl_x64-windows\include;D:\Keil_v5\ARM\PACK\Keil\STM32F1xx_DFP\2.4.1\Device\Include;D:\Keil_v5\ARM\PACK\ARM\CMSIS\5.8.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./API/: API.h Config.h
    ./main/include/: CallbackManager.h Handle.h Pin.h
    ./RTOS/include/: Loop.h Task.h Timer.h Global.h
    ./RTOS/EventLoop/: Global.cpp Loop.cpp Timer.cpp
    ./main/lib/: HAL.cpp Handle.cpp
  group start
    ./test/: run_test.c
software components: Device:Startup 1.0.0
